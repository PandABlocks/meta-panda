DESCRIPTION = "Tornado python package"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

inherit pypi setuptools3

SRC_URI[sha256sum] = "84ceece391e8eb9b2b95578db65e920d2a61070260594819589609ba9bc6308c"
PYPI_PACKAGE = "tornado"
