require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-FPGA/-/releases/4.2b1/downloads/panda-fpga-pandabox-fmc-acq427_4.2b1_all.ipk"
SRC_URI[sha256sum] = "6ddd69043042f6dcc7155280d7c75c09d7bc24089b9adac63779d08b6bea3794"
