require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.0alpha1/panda-fpga-doc@4.0-35-ged4bb44-dirty.ipk"
SRC_URI[sha256sum] = "d0e5385384f298fb1df9e0d6684f04cb14470f67a21c8a633fabe4943ab9d1a2"
