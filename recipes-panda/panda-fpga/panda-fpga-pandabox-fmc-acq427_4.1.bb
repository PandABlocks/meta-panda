require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.1/panda-fpga-pandabox-fmc-acq427_4.1_all.ipk"
SRC_URI[sha256sum] = "7d5f548a0846c5398cc680a47b43c4a0fdf3dc9e298d193d718eff68559530e7"
