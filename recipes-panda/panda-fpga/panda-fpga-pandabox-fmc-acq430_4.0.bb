require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.0alpha1/panda-fpga-pandabox-fmc-acq430@4.0-35-gb8f6de5-dirty.ipk"
SRC_URI[sha256sum] = "38749b9e69c3e2e3f1e787d1a08f6ab4f6202cb89b404e7d50c42a0aec6466d8"
