require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.0alpha1/panda-fpga-pandabox-fmc-24vio@4.0-35-gb8f6de5-dirty.ipk"
SRC_URI[sha256sum] = "12fb9200b14059526d26bc4b73fd65c0af918c50b6d05bf87a0e051fef804803"
