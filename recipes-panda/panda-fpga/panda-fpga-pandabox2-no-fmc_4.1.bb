require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.0alpha1/panda-fpga-pandabox2-no-fmc_4.1-2-g55067cc-dirty_all.ipk"
SRC_URI[sha256sum] = "f78890f7eb35567d87116d5c974b3b4cf8eea0ca667b2aef1e6629ecb4093043"
