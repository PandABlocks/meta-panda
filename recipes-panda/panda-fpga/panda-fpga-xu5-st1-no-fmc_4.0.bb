require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.0alpha1/panda-fpga-xu5-st1-no-fmc@4.0-35-gb8f6de5-dirty.ipk"
SRC_URI[sha256sum] = "b6feb3e6a54f04f81b46c965eaa5352b13cc9751bc2fbebf695861a57574f49f"
