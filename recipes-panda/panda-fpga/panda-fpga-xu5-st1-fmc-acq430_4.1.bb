require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.1/panda-fpga-xu5-st1-fmc-acq430_4.1_all.ipk"
SRC_URI[sha256sum] = "22234688fcf9ba1bb5082caa4f82d6ac83fe2dc2232191eb1c7334abca0e93d4"
