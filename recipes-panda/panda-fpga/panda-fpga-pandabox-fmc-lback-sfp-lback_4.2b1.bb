require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-FPGA/-/releases/4.2b1/downloads/panda-fpga-pandabox-fmc-lback-sfp-lback_4.2b1_all.ipk"
SRC_URI[sha256sum] = "47ab96843af40666fce066b4d6f49ca9b8cf843fc53a4f48f7957ae92184208e"
