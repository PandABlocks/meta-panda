require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-FPGA/-/releases/4.2b1/downloads/panda-fpga-pandabrick_4.2b1_all.ipk"
SRC_URI[sha256sum] = "4df4b674a42757e2438821b2242f7dc4daaf5cdfc9244786ceff77a3fde679bb"
