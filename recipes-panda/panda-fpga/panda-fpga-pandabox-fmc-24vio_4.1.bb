require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.1/panda-fpga-pandabox-fmc-24vio_4.1_all.ipk"
SRC_URI[sha256sum] = "6c9938ae4dd589fc7459f9fd105121e9ac42dd598deedcff568ae8d37717c839"
