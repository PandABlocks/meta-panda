require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.1/panda-fpga-pandabox-fmc-acq430_4.1_all.ipk"
SRC_URI[sha256sum] = "1c2d1712b794e5ca2b7162ac6a4b87fd315314d75d26b8c47b5aba49867605d4"
