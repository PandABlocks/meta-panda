require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-FPGA/-/releases/4.2b1/downloads/panda-fpga-pandabox2-no-fmc_4.2b1_all.ipk"
SRC_URI[sha256sum] = "ca59e7f22078d51e73dd04f735aba70ca8385bd15790fe2bdccd46be9d7081a9"
