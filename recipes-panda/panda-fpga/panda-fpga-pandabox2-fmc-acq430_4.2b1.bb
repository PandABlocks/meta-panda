require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-FPGA/-/releases/4.2b1/downloads/panda-fpga-pandabox2-fmc-acq430_4.2b1_all.ipk"
SRC_URI[sha256sum] = "31b306ea93b2f262bd9e75c4a3bddfbd3079358588f330fb5a9f722c33428006"
