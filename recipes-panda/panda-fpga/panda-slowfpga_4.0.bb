require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.0alpha1/panda-slowfpga@4.0-dirty.ipk"
SRC_URI[sha256sum] = "932b389642a9ef6dcd3ebe3cc8dafe3eb80e3284663a443ec07927da65b2cb13"
