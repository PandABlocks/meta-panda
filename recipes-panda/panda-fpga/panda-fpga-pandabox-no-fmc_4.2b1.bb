require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-FPGA/-/releases/4.2b1/downloads/panda-fpga-pandabox-no-fmc_4.2b1_all.ipk"
SRC_URI[sha256sum] = "d3780b60e14d802dec96fa3198a30680b70fd2a9824338d773c8cb12ea3bbfab"
