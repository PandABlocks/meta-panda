require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.1/panda-fpga-pandabox-fmc-lback-sfp-lback_4.1_all.ipk"
SRC_URI[sha256sum] = "57b66d9b7626967453164d041f6fe2bd2d909fbd3f6fdf2d11bdcd1b5a974dbe"
