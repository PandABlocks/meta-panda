require panda-fpga.inc

APP = "fmc_24vio"
SRC_URI:pandabox = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.0/panda-fpga@PandABox-fmc_24vio-4.0.zpg;name=pandabox-fmc_24vio"
SRC_URI[pandabox-fmc_24vio.sha256sum] = "efa039e1be717a074ebc0c8139ee40f518f1e40097f4ad294c7fea761fba1df5"
