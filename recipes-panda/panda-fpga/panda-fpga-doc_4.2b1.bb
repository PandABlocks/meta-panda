require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-FPGA/-/releases/4.2b1/downloads/panda-fpga-doc_4.2b1_all.ipk"
SRC_URI[sha256sum] = "6b4a382256b89956460c116826456e7dbee5cc42bb91ffa62cde95874482fb8b"
