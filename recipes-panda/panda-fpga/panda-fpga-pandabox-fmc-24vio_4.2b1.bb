require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-FPGA/-/releases/4.2b1/downloads/panda-fpga-pandabox-fmc-24vio_4.2b1_all.ipk"
SRC_URI[sha256sum] = "1d84a741da69c03006cf70bf7c9ea97729951822825024472b600537fef49ece"
