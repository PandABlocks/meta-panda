require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-FPGA/-/releases/4.2b1/downloads/panda-fpga-pandabox2-fmc-lback-sfp-sync_4.2b1_all.ipk"
SRC_URI[sha256sum] = "d7263bad87af2468065785b94051b251233ceddb7780912a1ebe85bf1cb7ac1b"
