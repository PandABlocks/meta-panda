require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.1/panda-fpga-pandabrick_4.1_all.ipk"
SRC_URI[sha256sum] = "dc0b07c4d6d2fc1943781dd03fa42caeb3f15d46bba97283e8ed07b251dfee4e"
