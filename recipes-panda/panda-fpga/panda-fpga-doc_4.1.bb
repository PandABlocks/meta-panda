require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.1/panda-fpga-doc_4.1_all.ipk"
SRC_URI[sha256sum] = "fb26c07850d2ec850e5df260144876862181cbb05e3887eb0cbd02dec5a1a949"
