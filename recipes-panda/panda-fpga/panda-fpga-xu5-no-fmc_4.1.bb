require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.2b1/panda-fpga-xu5-no-fmc_4.1-29-g950117b_all.ipk"
SRC_URI[sha256sum] = "fd20668f8226f32c8f92746c856369ed1769947a6829ce4df3ba955af02ff20b"
