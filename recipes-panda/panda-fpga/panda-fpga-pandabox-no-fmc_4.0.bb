require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.0alpha1/panda-fpga-pandabox-no-fmc@4.0-35-ged4bb44-dirty.ipk"
SRC_URI[sha256sum] = "6f7eb5a444c91c0128a2929db397765e6a15981bbc48f757cb01db9c9dd53136"
