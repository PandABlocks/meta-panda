require panda-fpga.inc

APP = "fmc_lback-sfp_lback"
SRC_URI:pandabox = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.0/panda-fpga@PandABox-fmc_lback-sfp_lback-4.0.zpg;name=pandabox-fmc_lback-sfp_lback"
SRC_URI[pandabox-fmc_lback-sfp_lback.sha256sum] = "b02eec88146a33b72fcd423c14050174eea236bbfcee7a1a6a213e10f1abb238"
