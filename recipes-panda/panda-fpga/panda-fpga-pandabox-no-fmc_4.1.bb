require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.1/panda-fpga-pandabox-no-fmc_4.1_all.ipk"
SRC_URI[sha256sum] = "d8deeed1d6da400e44bcec4b1f4572edd95834d55814c69bf394572b43a3bedb"
