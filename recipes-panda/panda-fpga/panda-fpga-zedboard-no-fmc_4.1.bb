require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.2b1/panda-fpga-zedboard-no-fmc_4.1-29-g950117b_all.ipk"
SRC_URI[sha256sum] = "ab9f654ad89f007e683a2336e0f2a051a84d75a340a1fac0bd6a07985d448114"
