require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.0alpha1/panda-fpga-pandabox-fmc-lback-sfp-lback@4.0-35-gb8f6de5-dirty.ipk"
SRC_URI[sha256sum] = "1ef74bb2ff7c641705974e4ad3358334f51837a0d27f5c13aea18d6efbd1bfd5"
