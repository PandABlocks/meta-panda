require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/meta-panda/releases/download/4.0alpha1/panda-fpga-xu5-st1-fmc-acq430@4.0-35-gb8f6de5-dirty.ipk"
SRC_URI[sha256sum] = "711ed984043f6bd1ffdc5d8d9f13bec07805160f491eb557a935584a75d26b08"
