require panda-fpga.inc

SRC_URI = "https://github.com/PandABlocks/PandABlocks-FPGA/releases/download/4.1/panda-fpga-xu5-st1-no-fmc_4.1_all.ipk"
SRC_URI[sha256sum] = "8f87b8190bf45011307ea1f459d1dcfbaf57f3b3b92ae303990e18f32f3da670"
