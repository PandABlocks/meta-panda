require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-FPGA/-/releases/4.2b1/downloads/panda-fpga-pandabox-fmc-acq430_4.2b1_all.ipk"
SRC_URI[sha256sum] = "cdc811fc02e6a5da14cf3e1e48c025913cd7d08a5d12eec4f1d6001c5232bf5f"
