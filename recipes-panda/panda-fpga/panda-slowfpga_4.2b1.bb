require panda-fpga.inc

SRC_URI = "https://gitlab.diamond.ac.uk/controls/hardware/PandABlocks-slowFPGA/-/releases/4.2b1/downloads/panda-slowfpga_4.2b1_all.ipk"
SRC_URI[sha256sum] = "47ef674b5f219885e8258f68b8e37f765a18baa0019f52b47809fefac0484983"
